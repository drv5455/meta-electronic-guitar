FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://electronic_guitar.cfg"
